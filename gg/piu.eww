<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lab4.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\Lab6EmptyUart\lab5.ewp</path>
    </project>
    <batchBuild />
</workspace>
